Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: Prana 410 BIM.IFC
Time: 2022-06-30T11:15:44
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Adressbaustein BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: A - LPS260 Mischbetrieb Adr. 1-32; Version 2: G - MSÜ-3-S Mischbetriebsbaustein; Version 3: S - SET10 Mischbetriebsbaustein; Version 4: T -ELC Mischbetriebsbaustein; Version 5: X - über beigestellten Baustein

# IfcBuildingElementProxy: Prana Einschaltoption BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: 00 - Ohne Option; Version 2: TS - mit TW500, DL über MW-Sensor; Version 3: US - DL ü.MW-Sensor, Not-BLF redzie

# IfcBuildingElementProxy: Prana LED Panel BIM_LED Panel 15W d=225mm
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: 15W3 - LED 15W >1600Lm 3000K >CR80; Version 2: 15W4 - LED 15W >1800Lm 4200K >CR80; Version 3: 16W3 - LED 16W >1600Lm 3000K >CR80; Version 4: 16W4 - LED 15W >1600Lm 4000K >CR80; Version 5: 20W3 - LED 20W >2400Lm 3000K >CR80; Version 6: 20W4 - LED 20W >2500Lm 4200K >CR80; Version 7: 32W3 - LED 32W >3200Lm 3000K >CR80; Version 8: 32W4 - LED 32W >3200Lm 4200K >CR80

# IfcBuildingElementProxy: Prana Leergehäuse Haube BIM_316700010 Prana Leergehäuse 410mm Haube
In: Default Storey
Material: PS mittlere/hohe Fließfähigkeit
SolidWorks Custom Properties - Material: PS mittlere/hohe Fließfähigkeit; Gewicht: 274.93

# IfcBuildingElementProxy: Prana Leergehäuse Sockel BIM_316700020 PRANA Leergehäuse 420mm
In: Default Storey
Material: AL Mg Si 0,5
SolidWorks Custom Properties - Material: AL Mg Si 0,5; Gewicht: 481.87; Farbe 1: Alu glänzend

# IfcBuildingElementProxy: Prana Montageblech BIM
In: Default Storey
Material: St12
SolidWorks Custom Properties - Material: St12; Gewicht: 562.31

# IfcBuildingElementProxy: Prana Montagefläche BIM
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Prana Technik BIM
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Version 1: C- zentr. Vers. AC/DC Adressmodul; Version 2: FM3 - AT.SD&BS,LFP 3,2V 3h RC250; Version 3: FM8 - AT.SD&BS,LFP 3,2V 8h RC250; Version 4: M3E - AT.DS&BS. LFP 3,2V 3h; Version 5: M8E - AT.DS&BS. LFP 3,2V 8h; Version 6: QDC - zenr.AC/DC Vers. DC-ECO Mode; Version 7: YDC - Mischbetrieb mit DC-ECO Mode

# IfcElementAssembly: Prana 410 BIM
In: Default Storey
SolidWorks Custom Properties - Montageart: Wand und Deckenmontage
PSet_Mass_Property - Mass Measure: 1.44247; Area Measure: 1.34465 m2; Volume Measure: 0.000637827 m3
