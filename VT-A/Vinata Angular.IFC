Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: H:\Mechanik\Solidworks\BIM\Vinata Angular\Vinata Angular BIM.IFC
Time: 2026-09-25T05:31:22+00:00
Author: none
Organization: none
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4
Authorization: none

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Area Measure: 0.7795730758992657; Mass Measure: 2.4029909709099209; Volume Measure: 0.0004977258803146

# IfcBuilding, default Building
PSet_Mass_Property - Area Measure: 0.7795730758992657; Mass Measure: 2.4029909709099209; Volume Measure: 0.0004977258803146

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Area Measure: 0.7795730758992657; Mass Measure: 2.4029909709099209; Volume Measure: 0.0004977258803146

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (6)
In: default BuildingStorey
Name | Gewicht | Material
Vinata angular Montageblech BIM | 98.10 | St12 | SOLIDWORKS Custom Properties - Artikelnr.: 899003355; Benennung dt.: Vinata angular Montageblech; Oberfläche: verzinkt; Revision: VII
Vinata Angular Gehäuse BIM | 1558,53 | Graues Gusseisen
Vinata Montagefläche BIM
VINATA angular Rahmen BIM | 515,65 | Graues Gusseisen
VINATA angular Haube BIM | 210,21 | PC
Vinata Technik BIM | SOLIDWORKS Custom Properties - Version 1: 0 - Ohne Treiber - NVB-2 erforderlich; Version 2: B - DALI2 zentr. Vers. Funktionsüberwacht; Version 3: C - zentr. Vers. Funktionsüberwacht; Version 4: D - DALI2 tentrale Versorgung AC/DC; Version 5: E - zentrale Versorgung AC/DC; Version 6: M - AUTOTEST, DS&BS, DL-Schalteingang; Version 7: MH - AT, DS&BS, DL-Schalteingang

# IfcElementAssembly, Vinata Angular BIM
In: default BuildingStorey
PSet_Mass_Property - Area Measure: 0.7795730758992657; Mass Measure: 2.4029909709099209; Volume Measure: 0.0004977258803146
