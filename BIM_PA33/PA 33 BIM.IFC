Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: H:\Mechanik\Solidworks\BIM\Prana\PA 33 BIM.IFC
Time: 2026-03-03T10:59:22+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
SOLIDWORKS Custom Properties - Montageart: Wand und Deckenmontage
PSet_Mass_Property - Area Measure: 1.1448582338287561; Mass Measure: 1.1946449362697451; Volume Measure: 0.0004983480277767

# IfcBuilding, default Building
SOLIDWORKS Custom Properties - Montageart: Wand und Deckenmontage
PSet_Mass_Property - Area Measure: 1.1448582338287561; Mass Measure: 1.1946449362697451; Volume Measure: 0.0004983480277767

# IfcBuildingStorey, default BuildingStorey
In: default Building
SOLIDWORKS Custom Properties - Montageart: Wand und Deckenmontage
PSet_Mass_Property - Area Measure: 1.1448582338287561; Mass Measure: 1.1946449362697451; Volume Measure: 0.0004983480277767

# IfcBuildingElementProxy: AECARCHITECTURALELEMENT (8)
In: default BuildingStorey
Name
Prana Technik BIM_Standard | SOLIDWORKS Custom Properties - Version 1: C- zentr. Vers. AC/DC Adressmodul; Version 2: FM3 - AT.SD&BS,LFP 3,2V 3h RC250; Version 3: FM8 - AT.SD&BS,LFP 3,2V 8h RC250; Version 4: M3E - AT.DS&BS. LFP 3,2V 3h; Version 5: M8E - AT.DS&BS. LFP 3,2V 8h; Version 6: QDC - zenr.AC/DC Vers. DC-ECO Mode; Version 7: YDC - Mischbetrieb mit DC-ECO Mode
Prana LED Panel BIM_LED Panel 15W d=225mm | SOLIDWORKS Custom Properties - Version 1: 15W3 - LED 15W >1600Lm 3000K >CR80; Version 2: 15W4 - LED 15W >1800Lm 4200K >CR80; Version 3: 16W3 - LED 16W >1600Lm 3000K >CR80; Version 4: 16W4 - LED 15W >1600Lm 4000K >CR80; Version 5: 20W3 - LED 20W >2400Lm 3000K >CR80; Version 6: 20W4 - LED 20W >2500Lm 4200K >CR80; Version 7: 32W3 - LED 32W >3200Lm 3000K >CR80; Version 8: 32W4 - LED 32W >3200Lm 4200K >CR80
Prana Leergehäuse Sockel BIM_316700040 PRANA Leergehäuse 330mm | SOLIDWORKS Custom Properties - Farbe 1: Alu glänzend; Gewicht: 196.30; Material: AL Mg Si 0,5
Prana Montageblech BIM_Standard | SOLIDWORKS Custom Properties - Gewicht: 562.31; Material: St12
Prana Montagefläche BIM_Standard
Prana Einschaltoption BIM_Standard | SOLIDWORKS Custom Properties - Version 1: 00 - Ohne Option; Version 2: TS - mit TW500, DL über MW-Sensor; Version 3: US - DL ü.MW-Sensor, Not-BLF redzie
Adressbaustein BIM_Standard | SOLIDWORKS Custom Properties - Version 1: A - LPS260 Mischbetrieb Adr. 1-32; Version 2: G - MSÜ-3-S Mischbetriebsbaustein; Version 3: S - SET10 Mischbetriebsbaustein; Version 4: T -ELC Mischbetriebsbaustein; Version 5: X - über beigestellten Baustein; Version 6: L - SUB-C- LBG Adressbaustein
Prana Leergehäuse Haube BIM_31670030 PRANA Leergehäuse 330mm | SOLIDWORKS Custom Properties - Gewicht: 274.93; Material: PS mittlere/hohe Fließfähigkeit

# IfcElementAssembly, Prana BIM
In: default BuildingStorey
SOLIDWORKS Custom Properties - Montageart: Wand und Deckenmontage
PSet_Mass_Property - Area Measure: 1.1448582338287561; Mass Measure: 1.1946449362697451; Volume Measure: 0.0004983480277767
